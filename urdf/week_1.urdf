Commit message: actualitzar

File: urdf/week_1.urdf (robot description, URDF)
Before this commit: robot materials, 3 links, 2 joints
Joints:
- joint wheel1_to_wheel_2: axis 0 1.5 0 -> 0 1.57075 0; origin xyz=0 0 0 -> xyz=0 0 0.0675
- joint wheel1_to_wheel_3: origin xyz=0 0 0.2 -> xyz=0 0 0.0675
